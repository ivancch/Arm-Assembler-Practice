# Keil uVision project AssemblerPractice.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: AssemblerPractice
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group StartUpAndInterrupts
    ./src/StartUpAndInterrupts/: StartUp1.s NMI.s
  group AssemblerPractice
    ./src/AssemblerPractice/: Main.s 1SimpleOperations.s 2_32bitConst.s 3ForcedReservationLTORG.s 4ReservationDirective.s 5IndirectAddressing.s
